options:
  parameters:
    generate_options: no_gui
    id: start_radio
    output_language: python
    run_options: run
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: '500'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_size
  states: {}
- name: blocks_complex_to_mag_squared_1
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_size
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: '"sky_spectrum_{}_{}_{}.dat".format(tuning_freq, samp_rate, fft_size)'
    type: float
    unbuffered: 'True'
    vlen: fft_size
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: '"cal_spectrum_{}_{}_{}.dat".format(tuning_freq, samp_rate, fft_size)'
    type: float
    unbuffered: 'True'
    vlen: fft_size
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: fft_size*int(samp_rate*int_time / fft_size)
    type: complex
  states: {}
- name: blocks_head_1
  id: blocks_head
  parameters:
    num_items: fft_size*int(samp_rate*int_time / fft_size)
    type: complex
  states: {}
- name: blocks_integrate_xx_1_0
  id: blocks_integrate_xx
  parameters:
    decim: decimation
    type: float
    vlen: fft_size
  states: {}
- name: blocks_integrate_xx_1_0_0
  id: blocks_integrate_xx
  parameters:
    decim: decimation
    type: float
    vlen: fft_size
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: fft_size
  id: parameter
  parameters:
    type: intx
    value: '512'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    nthreads: '4'
    shift: 'True'
    type: complex
    window: window.hamming(fft_size)
  states: {}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    nthreads: '4'
    shift: 'True'
    type: complex
    window: window.hamming(fft_size)
  states: {}
- name: filter_bw
  id: parameter
  parameters:
    type: intx
    value: '20000000'
  states: {}
- name: gain
  id: parameter
  parameters:
    type: eng_float
    value: '64'
  states: {}
- name: int_time
  id: parameter
  parameters:
    type: intx
    value: '150'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"rtl_tcp=127.0.0.1:5000"'
    bb_gain0: '20'
    freq0: tuning_freq
    gain0: '49.6'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_source_0_0
  id: osmosdr_source
  parameters:
    args: '"rtl_tcp=127.0.0.1:5001"'
    bb_gain0: '20'
    freq0: tuning_freq
    gain0: '49.6'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    type: intx
    value: '2000000'
  states: {}
- name: tuning_freq
  id: parameter
  parameters:
    type: intx
    value: '1420405752'
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_1_0, '0']
- [blocks_complex_to_mag_squared_1, '0', blocks_integrate_xx_1_0_0, '0']
- [blocks_head_0, '0', blocks_stream_to_vector_1, '0']
- [blocks_head_1, '0', blocks_stream_to_vector_0, '0']
- [blocks_integrate_xx_1_0, '0', blocks_file_sink_0, '0']
- [blocks_integrate_xx_1_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_1, '0']
- [blocks_stream_to_vector_1, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [fft_vxx_1, '0', blocks_complex_to_mag_squared_1, '0']
- [osmosdr_source_0, '0', blocks_head_0, '0']
- [osmosdr_source_0_0, '0', blocks_head_1, '0']

metadata:
  file_format: 1
